<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Graphic LCD 192x64.ewp</path>
  </project>
  <batchBuild />
</workspace>
